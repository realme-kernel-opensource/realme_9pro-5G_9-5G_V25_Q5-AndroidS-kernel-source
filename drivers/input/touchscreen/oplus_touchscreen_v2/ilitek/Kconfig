## drivers/input/touchscreen/oplus_touchscreen_v2/ilitek/Kconfig
```kconfig
source "drivers/input/touchscreen/oplus_touchscreen_v2/ilitek/ilitek7807s/Kconfig"
```
